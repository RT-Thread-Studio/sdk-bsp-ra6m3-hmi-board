# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA6M3AH Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: IRAM(0x1FFE0000,0x020000) IRAM2(0x20000000,0x080000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, __RTTHREAD__, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall  -Wmissing-declarations  -Wpointer-arith  -Waggregate-return -Wfloat-equal
  c include: packages/LVGL-v8.3.8/src/extra/libs/qrcode;packages/LVGL-v8.3.8/src/extra/widgets/animimg;packages/LVGL-v8.3.8/src/misc;packages/LVGL-v8.3.8/src/draw/arm2d;packages/LVGL-v8.3.8/src/extra/others/monkey;board/lvgl/demo/ebike/fonts;board/ports;packages/LVGL-v8.3.8/src/extra/widgets/tabview;packages/LVGL-v8.3.8/src/extra;rt-thread/components/libc/compilers/common/include;rt-thread/components/libc/compilers/common/extension;packages/LVGL-v8.3.8/src/extra/libs/rlottie;rt-thread/include;board/lvgl/demo/ebike;rt-thread/components/drivers/include;packages/LVGL-v8.3.8/src/extra/others/snapshot;rt-thread/components/drivers/include;packages/LVGL-v8.3.8/src/font;packages/LVGL-v8.3.8/src/extra/themes;packages/LVGL-v8.3.8/src/draw/swm341_dma2d;packages/LVGL-v8.3.8/src/draw/stm32_dma2d;packages/LVGL-v8.3.8/src/extra/layouts/grid;packages/LVGL-v8.3.8/src/extra/widgets/msgbox;packages/LVGL-v8.3.8/src/draw/nxp/vglite;packages/LVGL-v8.3.8/src/extra/widgets/spinbox;packages/LVGL-v8.3.8/src/extra/widgets/meter;packages/LVGL-v8.3.8/src/extra/libs/sjpg;packages/LVGL-v8.3.8/src/extra/libs/freetype;packages/LVGL-v8.3.8/src/draw/sdl;packages/LVGL-v8.3.8/src/extra/others/ime;packages/LVGL-v8.3.8/src/core;packages/LVGL-v8.3.8/src/draw/sw;board/lvgl/demo/ebike/images;packages/LVGL-v8.3.8/src/extra/others/gridnav;rt-thread/components/drivers/include;rt-thread/libcpu/arm/cortex-m4;packages/LVGL-v8.3.8/env_support/rt-thread;packages/LVGL-v8.3.8/env_support/rt-thread/squareline/ui/lvgl;rt-thread/components/libc/posix/ipc;packages/LVGL-v8.3.8/src/widgets;board/ports/wifi;libraries/HAL_Drivers;packages/LVGL-v8.3.8/src/draw;packages/LVGL-v8.3.8/src/extra/layouts/flex;packages/LVGL-v8.3.8/src/extra/widgets/span;packages/LVGL-v8.3.8/src/extra/themes/default;board/lvgl/demo/ebike/components;packages/LVGL-v8.3.8/src/extra/widgets/tileview;packages/LVGL-v8.3.8/src/extra/libs/fsdrv;packages/LVGL-v8.3.8/src/extra/widgets/win;packages/LVGL-v8.3.8/src/extra/others;packages/LVGL-v8.3.8/src;packages/LVGL-v8.3.8/src/extra/widgets/list;packages/LVGL-v8.3.8/src/extra/libs/ffmpeg;packages/LVGL-v8.3.8/src/extra/widgets/led;packages/LVGL-v8.3.8/src/extra/widgets/spinner;packages/LVGL-v8.3.8/src/extra/widgets/menu;board/lvgl;packages/LVGL-v8.3.8/src/extra/widgets/keyboard;packages/LVGL-v8.3.8/src/extra/libs/bmp;packages/LVGL-v8.3.8/src/extra/widgets/calendar;packages/LVGL-v8.3.8/src/extra/layouts;packages/LVGL-v8.3.8/src/draw/nxp/pxp;packages/LVGL-v8.3.8/src/extra/others/fragment;board;rt-thread/components/drivers/include;board/lvgl/demo/ebike/screens;board/lvgl/demo;packages/LVGL-v8.3.8/src/extra/widgets;rt-thread/components/drivers/include;packages/LVGL-v8.3.8/src/extra/others/imgfont;packages/LVGL-v8.3.8/env_support/rt-thread/squareline;packages/LVGL-v8.3.8/src/hal;rt-thread/components/libc/posix/io/poll;packages/LVGL-v8.3.8/src/extra/themes/mono;packages/LVGL-v8.3.8/src/extra/widgets/chart;.;packages/LVGL-v8.3.8/src/extra/others/msg;packages/LVGL-v8.3.8/src/extra/libs/png;libraries/HAL_Drivers/config;rt-thread/components/drivers/touch;packages/LVGL-v8.3.8/src/extra/libs;rt-thread/components/libc/compilers/common/extension/fcntl/octal;packages/LVGL-v8.3.8/src/extra/widgets/colorwheel;packages/LVGL-v8.3.8/src/extra/themes/basic;rt-thread/components/finsh;rt-thread/components/libc/posix/io/stdio;packages/LVGL-v8.3.8/src/extra/widgets/imgbtn;packages/LVGL-v8.3.8/src/draw/renesas;board/ports/touch/gt911/inc;rt-thread/libcpu/arm/common;packages/LVGL-v8.3.8/src/extra/libs/gif
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/touch/: touch.c
  group Drivers
    board/ports/: drv_g2d.c
    board/: ra6m3_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_lcd.c drv_pwm.c drv_soft_i2c.c drv_usart_v2.c
  group ebike-demo
    board/lvgl/demo/ebike/components/: ui_comp_hook.c
    board/lvgl/demo/ebike/fonts/: ui_font_Big.c ui_font_Medium.c ui_font_Number.c ui_font_Small.c
    board/lvgl/demo/ebike/images/: ui_img_battery_bg_png.c ui_img_ebike_bg_png.c ui_img_icn_battery_png.c ui_img_icn_bike_png.c ui_img_icn_charge_png.c ui_img_icn_flash_png.c ui_img_icn_lock_png.c ui_img_icn_ok_png.c ui_img_icn_x_png.c ui_img_menu_line_png.c ui_img_menu_on_png.c ui_img_particle_1_png.c ui_img_particle_2_png.c ui_img_particle_3_png.c ui_img_pin_line_png.c ui_img_pin_on_png.c ui_img_slider_battery_png.c ui_img_speed_slider_png.c ui_img_water_1_png.c ui_img_water_2_png.c
    board/lvgl/demo/ebike/screens/: ui_Driving.c
    board/lvgl/demo/ebike/: ui.c ui_helpers.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group gt911
    board/ports/touch/gt911/src/: gt911.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_up.c thread.c timer.c
  group LVGL
    packages/LVGL-v8.3.8/src/widgets/: lv_img.c lv_btn.c lv_bar.c lv_arc.c lv_line.c lv_table.c lv_btnmatrix.c lv_objx_templ.c lv_dropdown.c lv_textarea.c lv_label.c lv_canvas.c lv_roller.c lv_slider.c lv_checkbox.c lv_switch.c
    packages/LVGL-v8.3.8/src/font/: lv_font_montserrat_28_compressed.c lv_font_montserrat_14.c lv_font_montserrat_10.c lv_font_montserrat_22.c lv_font_loader.c lv_font_montserrat_40.c lv_font_montserrat_38.c lv_font_montserrat_32.c lv_font_montserrat_30.c lv_font_unscii_8.c lv_font_montserrat_16.c lv_font_montserrat_28.c lv_font_unscii_16.c lv_font_simsun_16_cjk.c lv_font.c lv_font_montserrat_44.c lv_font_montserrat_24.c lv_font_montserrat_34.c lv_font_montserrat_46.c lv_font_montserrat_12.c lv_font_montserrat_8.c lv_font_montserrat_12_subpx.c lv_font_montserrat_42.c lv_font_montserrat_36.c lv_font_montserrat_26.c lv_font_fmt_txt.c lv_font_montserrat_18.c lv_font_montserrat_48.c lv_font_montserrat_20.c lv_font_dejavu_16_persian_hebrew.c
    packages/LVGL-v8.3.8/src/misc/: lv_templ.c lv_tlsf.c lv_lru.c lv_utils.c lv_log.c lv_timer.c lv_fs.c lv_txt.c lv_style.c lv_mem.c lv_anim_timeline.c lv_printf.c lv_bidi.c lv_ll.c lv_math.c lv_anim.c lv_txt_ap.c lv_style_gen.c lv_color.c lv_async.c lv_area.c lv_gc.c
    packages/LVGL-v8.3.8/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_vglite_utils.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_draw_vglite.c
    packages/LVGL-v8.3.8/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.8/src/draw/sdl/: lv_draw_sdl_texture_cache.c lv_draw_sdl_polygon.c lv_draw_sdl_mask.c lv_draw_sdl_bg.c lv_draw_sdl_line.c lv_draw_sdl_rect.c lv_draw_sdl_img.c lv_draw_sdl_composite.c lv_draw_sdl_label.c lv_draw_sdl_arc.c lv_draw_sdl.c lv_draw_sdl_layer.c lv_draw_sdl_stack_blur.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.8/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_img.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_letter.c lv_draw_sw_gradient.c lv_draw_sw_dither.c lv_draw_sw_blend.c lv_draw_sw_layer.c lv_draw_sw.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.8/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.8/src/core/: lv_event.c lv_disp.c lv_obj_draw.c lv_refr.c lv_obj_class.c lv_obj_scroll.c lv_indev.c lv_group.c lv_obj_style.c lv_theme.c lv_obj_tree.c lv_obj_style_gen.c lv_indev_scroll.c lv_obj_pos.c lv_obj.c
    packages/LVGL-v8.3.8/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.8/src/draw/: lv_draw_arc.c lv_draw_layer.c lv_draw_mask.c lv_draw.c lv_draw_transform.c lv_img_decoder.c lv_draw_rect.c lv_draw_triangle.c lv_draw_img.c lv_draw_label.c lv_img_buf.c lv_draw_line.c lv_img_cache.c
    packages/LVGL-v8.3.8/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.8/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.8/src/hal/: lv_hal_indev.c lv_hal_tick.c lv_hal_disp.c
    packages/LVGL-v8.3.8/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.8/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.8/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.8/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.8/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.8/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.8/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.8/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_posix.c lv_fs_stdio.c lv_fs_fatfs.c
    packages/LVGL-v8.3.8/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.8/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.8/src/draw/nxp/pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c lv_draw_pxp.c
    packages/LVGL-v8.3.8/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.8/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.8/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.8/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.8/src/extra/: lv_extra.c
    packages/LVGL-v8.3.8/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.8/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.8/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.8/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.8/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.8/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.8/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.8/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.8/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.8/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.8/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.8/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.8/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.8/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.8/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.8/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.8/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.8/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.8/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.8/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.8/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.8/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.8/src/extra/widgets/led/: lv_led.c
  group LVGL-demo
    board/lvgl/demo/: lv_demo.c
    packages/lv_music_demo-v0.3.3/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c
    packages/lv_music_demo-v0.3.3/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.8/env_support/rt-thread/: lv_rt_thread_port.c
  group LVGL-SquareLine
    packages/LVGL-v8.3.8/env_support/rt-thread/squareline/: lv_ui_entry.c
software components: Flex Software:RA Configuration 1.0.0
