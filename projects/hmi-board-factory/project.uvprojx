# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA6M3AH Renesas
  pack: Renesas.RA_DFP.4.2.0
  cpu: IRAM(0x1FFE0000,0x020000) IRAM2(0x20000000,0x080000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall  -Wmissing-declarations  -Wpointer-arith  -Waggregate-return -Wfloat-equal
  c include: packages\LVGL-v8.3.5\src\extra\libs\bmp;packages\rw007-latest;packages\LVGL-v8.3.5\src\extra\themes\default;packages\LVGL-v8.3.5\src;packages\LVGL-v8.3.5\src\extra\others\monkey;packages\LVGL-v8.3.5\src\extra\libs\ffmpeg;board\ports\wifi;rt-thread\components\dfs\filesystems\devfs;packages\LVGL-v8.3.5\src\extra\widgets\imgbtn;board\lvgl\demo;packages\LVGL-v8.3.5\src\draw\nxp\pxp;packages\rw007-latest\inc;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.5\src\draw\stm32_dma2d;packages\LVGL-v8.3.5\src\extra\themes\mono;packages\LVGL-v8.3.5\src\extra\others\snapshot;packages\LVGL-v8.3.5\src\extra\libs;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\layouts\flex;board\lvgl\demo\factory_demo\IMG;packages\LVGL-v8.3.5\src\extra\widgets\span;rt-thread\components\net\lwip\lwip-2.0.3\src\include;packages\LVGL-v8.3.5\src\extra\widgets\animimg;packages\LVGL-v8.3.5\src\extra\libs\freetype;rt-thread\components\libc\posix\io\poll;board\lvgl\demo\file_explorer;board\lvgl\lv_gpu_port;packages\LVGL-v8.3.5\src\draw\sw;packages\LVGL-v8.3.5\src\extra\libs\rlottie;packages\LVGL-v8.3.5\src\extra\libs\png;rt-thread\components\libc\posix\ipc;rt-thread\components\net\sal\include;packages\LVGL-v8.3.5\src\extra\others\ime;board\ports\avi;rt-thread\components\drivers\spi;board\lvgl\demo\factory_demo;packages\LVGL-v8.3.5\src\extra\others\msg;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\widgets\spinbox;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\draw\nxp\vglite;packages\LVGL-v8.3.5\src\extra\widgets\spinner;rt-thread\components\net\sal\include\socket;packages\LVGL-v8.3.5\src\draw\arm2d;packages\LVGL-v8.3.5\src\extra\widgets\keyboard;packages\LVGL-v8.3.5\src\extra\libs\fsdrv;packages\LVGL-v8.3.5\src\misc;packages\LVGL-v8.3.5\src\extra\others\imgfont;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\wlan;packages\LVGL-v8.3.5\env_support\rt-thread;packages\LVGL-v8.3.5\src\extra\widgets;packages\LVGL-v8.3.5\src\extra\libs\qrcode;rt-thread\components\net\sal\include\socket\sys_socket;packages\LVGL-v8.3.5\src\widgets;rt-thread\libcpu\arm\common;rt-thread\components\net\netdev\include;packages\LVGL-v8.3.5\src\extra\layouts\grid;board\lvgl;rt-thread\components\finsh;board\lvgl\demo\factory_demo\Page;libraries\HAL_Drivers\config;rt-thread\components\drivers\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\LVGL-v8.3.5\src\extra\widgets\meter;packages\LVGL-v8.3.5\src\extra\others\gridnav;packages\LVGL-v8.3.5\src\extra\widgets\calendar;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\widgets\menu;board\ports\touch\gt911\inc;rt-thread\include;rt-thread\components\dfs\include;packages\LVGL-v8.3.5\src\draw\sdl;packages\LVGL-v8.3.5\src\draw\swm341_dma2d;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\layouts;board;packages\tlsf-v1.0.0\src;libraries\HAL_Drivers;packages\LVGL-v8.3.5\src\extra\libs\gif;packages\LVGL-v8.3.5\src\extra\widgets\colorwheel;rt-thread\components\net\sal\impl;packages\LVGL-v8.3.5\src\extra\widgets\win;board\lvgl\demo\video\img;rt-thread\components\drivers\include;packages\LVGL-v8.3.5\src\extra\widgets\tileview;packages\LVGL-v8.3.5\src\extra\others\fragment;packages\LVGL-v8.3.5\src\extra\libs\sjpg;.;packages\LVGL-v8.3.5\src\extra\widgets\tabview;packages\LVGL-v8.3.5\src\extra;board\ports\avi\player;packages\LVGL-v8.3.5\src\extra\others;packages\LVGL-v8.3.5\src\core;rt-thread\components\libc\posix\io\stdio;packages\LVGL-v8.3.5\src\extra\widgets\led;rt-thread\components\net\lwip\port;board\ports;packages\LVGL-v8.3.5\src\extra\themes\basic;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;packages\LVGL-v8.3.5\src\extra\widgets\chart;packages\LVGL-v8.3.5\src\hal;rt-thread\components\drivers\touch;rt-thread\components\dfs\filesystems\elmfat;packages\LVGL-v8.3.5\src\extra\widgets\msgbox;packages\LVGL-v8.3.5\src\extra\widgets\list;packages\LVGL-v8.3.5\src\draw;packages\LVGL-v8.3.5\src\extra\themes;packages\LVGL-v8.3.5\src\font;board\ports\audio;rt-thread\components\libc\compilers\common\extension
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  group audio
    board/ports/audio/: pwm_audio.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    rt-thread/components/drivers/serial/: serial_v2.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/touch/: touch.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/ports/: drv_g2d.c drv_jpeg.c mnt.c
    board/ports/wifi/: drv_rw007.c
    board/: ra6m3_it.c
    libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_lcd.c drv_pwm.c drv_sci_spi.c drv_sdhi.c drv_soft_i2c.c drv_usart_v2.c
  group factory-demo
    board/lvgl/demo/factory_demo/: DisplayAppWin.c DisplayBasic.c DisplayPage.c PageManager.c WIFIComm.c lv_theme_conf.c
    board/lvgl/demo/factory_demo/IMG/: IMG_ETH.c IMG_FileExplorer.c IMG_Forward.c IMG_Game2048.c IMG_Info.c IMG_LEDAndBtn.c IMG_Logo.c IMG_Music.c IMG_QRCode.c IMG_Recorder.c IMG_SDCard.c IMG_Stop.c IMG_Tape.c IMG_VOLDown.c IMG_VOLUP.c IMG_WiFi.c
    board/lvgl/demo/factory_demo/Page/: Page_DemoLogo.c Page_ETH.c Page_EXAMPLE.c Page_Game2048.c Page_Info.c Page_LEDAndBtn.c Page_MainMenu.c Page_SDCard.c Page_VideoPlayer.c Page_WiFi.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group gt911
    board/ports/touch/gt911/src/: gt911.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mempool.c object.c scheduler_up.c thread.c timer.c
  group LVGL
    packages/LVGL-v8.3.5/src/font/: lv_font_montserrat_42.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_40.c lv_font_montserrat_24.c lv_font_montserrat_34.c lv_font_montserrat_32.c lv_font_montserrat_26.c lv_font_montserrat_10.c lv_font_montserrat_36.c lv_font_montserrat_44.c lv_font_loader.c lv_font_montserrat_48.c lv_font_montserrat_28_compressed.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font.c lv_font_montserrat_22.c lv_font_montserrat_14.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_28.c lv_font_montserrat_38.c lv_font_unscii_8.c lv_font_montserrat_30.c lv_font_unscii_16.c lv_font_montserrat_16.c lv_font_montserrat_46.c
    packages/LVGL-v8.3.5/src/draw/: lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_line.c lv_img_decoder.c lv_draw_transform.c lv_draw_layer.c lv_draw.c lv_img_cache.c lv_img_buf.c lv_draw_img.c lv_draw_arc.c lv_draw_label.c
    packages/LVGL-v8.3.5/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.5/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.5/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.5/src/draw/sdl/: lv_draw_sdl_bg.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_arc.c lv_draw_sdl_texture_cache.c lv_draw_sdl_layer.c lv_draw_sdl_composite.c lv_draw_sdl_stack_blur.c lv_draw_sdl_img.c lv_draw_sdl_mask.c lv_draw_sdl_rect.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_polygon.c
    packages/LVGL-v8.3.5/src/core/: lv_indev_scroll.c lv_obj_scroll.c lv_obj_draw.c lv_theme.c lv_obj_tree.c lv_refr.c lv_obj_style.c lv_indev.c lv_disp.c lv_obj.c lv_obj_pos.c lv_obj_class.c lv_event.c lv_obj_style_gen.c lv_group.c
    packages/LVGL-v8.3.5/src/draw/nxp/vglite/: lv_draw_vglite_rect.c lv_draw_vglite_arc.c lv_vglite_utils.c lv_draw_vglite_line.c lv_draw_vglite_blend.c lv_draw_vglite.c lv_vglite_buf.c
    packages/LVGL-v8.3.5/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_win32.c lv_fs_stdio.c
    packages/LVGL-v8.3.5/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.5/src/draw/sw/: lv_draw_sw_blend.c lv_draw_sw_gradient.c lv_draw_sw_dither.c lv_draw_sw_line.c lv_draw_sw_rect.c lv_draw_sw_layer.c lv_draw_sw_polygon.c lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.5/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.5/src/widgets/: lv_arc.c lv_dropdown.c lv_img.c lv_line.c lv_canvas.c lv_label.c lv_textarea.c lv_switch.c lv_objx_templ.c lv_slider.c lv_table.c lv_btn.c lv_btnmatrix.c lv_checkbox.c lv_bar.c lv_roller.c
    packages/LVGL-v8.3.5/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.5/src/misc/: lv_ll.c lv_templ.c lv_txt_ap.c lv_anim.c lv_math.c lv_color.c lv_mem.c lv_fs.c lv_log.c lv_timer.c lv_area.c lv_tlsf.c lv_txt.c lv_async.c lv_bidi.c lv_anim_timeline.c lv_gc.c lv_utils.c lv_style_gen.c lv_lru.c lv_style.c lv_printf.c
    packages/LVGL-v8.3.5/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.5/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.5/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.5/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3.5/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.5/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_dropdown.c lv_calendar_header_arrow.c
    packages/LVGL-v8.3.5/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.5/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.5/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.5/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.5/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.5/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.5/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.5/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.5/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.5/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.5/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.5/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.5/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.5/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.5/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.5/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.5/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.5/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.5/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.5/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.5/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.5/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.3.5/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.5/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.5/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.5/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.5/src/extra/: lv_extra.c
    packages/LVGL-v8.3.5/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.5/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.5/src/extra/others/snapshot/: lv_snapshot.c
  group LVGL-demo
    board/lvgl/demo/file_explorer/: lv_file_explorer.c
    board/lvgl/demo/: lv_demo.c
    board/lvgl/demo/video/img/: file_icon.c ui_img_audio_wave_1_png.c ui_img_indicator_ver_png.c ui_img_next_png.c ui_img_pause_png.c ui_img_prev_png.c ui_img_run_png.c
    packages/lv_music_demo-v0.3.2/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c
    packages/lv_music_demo-v0.3.2/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    board/lvgl/lv_gpu_port/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.5/env_support/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group player
    board/ports/avi/: avifile.c
    board/ports/avi/player/: player.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group tlsf
    packages/tlsf-v1.0.0/src/: tlsf.c
    packages/tlsf-v1.0.0/: rt_tlsf.c
software components: Flex Software:RA Configuration 1.0.0
